# Keil uVision project Project.uvprojx, settings and files
target Project (6160000::V6.16::ARMCLANG)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 wLevel=3
  c include: ..\..\..\IdeSupport\MDK;..\..\..\Libraries\inc;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../../../IdeSupport/MDK/: startup_cw32l010.s
    ../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c
  group BSP
    ../USER/src/: bsp_i2c.c bsp_oled.c bsp_oled_text.c bsp_pwm.c bsp_adc.c bsp_button.c
    ..//USER//src//: bsp_timer.c bsp_power.c bsp_detect.c
  group Driver
    ../../../Libraries/src/: cw32l010_sysctrl.c cw32l010_gpio.c cw32l010_flash.c cw32l010_atim.c cw32l010_adc.c
    ..//..//..//Libraries//src//: cw32l010_btim.c cw32l010_pwr.c
  group Utilities
    ../../../Utilities/: retarget.c
software components: CMSIS:CORE 6.1.1
